# Keil uVision project HSUSBD_HID_Transfer.uvprojx, settings and files
target HSUSBD_HID_Transfer (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: .\FILESUM ".\obj\@L.bin" ".\obj\@L_SUM.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\HSUSBD_svf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_m460.s
  group User
    ../: main.c descriptors.c hid_transfer.c usb_sn.c cpld_fan.c nvme_mi.c log_dump.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c gpio.c timer.c fmc.c i2c.c eadc.c usci_i2c.c
  group libxsvf
    ../: xsvftool-m031.c memname.c play.c scan.c statename.c svf.c tap.c xsvf.c
